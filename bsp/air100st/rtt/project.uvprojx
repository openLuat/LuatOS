# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, LFS_CONFIG=lfs_config.h, RT_USING_ARM_LIBC
  c include: applications;.;.;..\..\..\luat\packages\heap;..\..\..\luat\packages\lua-cjson;..\..\..\..\rt-thread\libcpu\arm\common;..\..\..\..\rt-thread\libcpu\arm\cortex-m4;..\..\..\..\rt-thread\components\drivers\hwcrypto;.;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\drivers\spi;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\drivers\spi\sfud\inc;..\..\..\..\rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\..\..\..\rt-thread\bsp\stm32\libraries\HAL_Drivers;..\..\..\..\rt-thread\bsp\stm32\libraries\HAL_Drivers\config;..\..\..\..\rt-thread\bsp\stm32\libraries\HAL_Drivers\drv_flash;packages\fal-v0.5.0\inc;..\..\..\..\rt-thread\components\dfs\include;..\..\..\..\rt-thread\components\dfs\filesystems\devfs;..\..\..\..\rt-thread\components\dfs\filesystems\elmfat;..\..\..\..\rt-thread\components\finsh;.;..\..\..\..\rt-thread\include;..\..\..\..\rt-thread\components\libc\compilers\armlibc;..\..\..\..\rt-thread\components\libc\compilers\common;packages\littlefs-v2.0.5;..\..\..\lua\include;..\..\..\luat\packages\minmea;..\..\..\luat\modules;..\..\..\luat\include;..\..\..\luat\packages\vsprintf;..\..\..\luat\packages\minmea;..\..\..\luat\packages\lua-cjson;..\..\..\luat\packages\vsprintf;..\..\..\..\rt-thread\components\drivers\usb\usbdevice;..\..\..\luat\rtt;..\..\..\luat\include;..\..\..\luat\packages\vsprintf;..\..\..\luat\packages\lfs;..\..\..\luat\packages\airkiss;..\..\..\luat\packages\fatfs;..\..\..\luat\packages\u8g2;..\..\..\..\rt-thread\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\..\rt-thread\bsp\stm32\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\rt-thread\bsp\stm32\libraries\STM32F4xx_HAL\CMSIS\Include;..\..\..\..\rt-thread\components\utilities\ulog;..\..\..\..\rt-thread\components\utilities\ymodem
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group bget
    ../../../luat/packages/heap/: bget.c
  group cjson
    ../../../luat/packages/lua-cjson/: fpconv.c lua_cjson.c strbuf.c
  group cpu
    ../../../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../../rt-thread/components/drivers/hwcrypto/: hwcrypto.c hw_rng.c
    ../../../../rt-thread/components/drivers/misc/: pin.c
    ../../../../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../../../../rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../../rt-thread/components/drivers/serial/: serial.c
    ../../../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: spi_flash_init.c sdcard_port.c
    ../../../../rt-thread/bsp/stm32/libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../../../../rt-thread/bsp/stm32/libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_crypto.c drv_sdio.c drv_common.c
    ../../../../rt-thread/bsp/stm32/libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.5.0/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../../../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../../rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group finsh
    ../../../../rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    ../../../../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../../../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../../rt-thread/components/libc/compilers/common/: time.c
  group littlefs
    packages/littlefs-v2.0.5/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group Lua
    ../../../lua/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltests.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c rotable.c
  group minmea
    ../../../luat/packages/minmea/: minmea.c
  group modules
    ../../../luat/modules/: crc.c luat_fs_weak.c luat_lib_crypto.c luat_lib_ctiot.c luat_lib_fs.c luat_lib_gpio.c luat_lib_libcoap.c luat_lib_libgnss.c luat_lib_log.c luat_lib_mqttcore.c luat_lib_pack.c luat_lib_rtos.c luat_lib_sensor.c luat_lib_spi.c luat_lib_timer.c luat_lib_uart.c luat_log_weak.c luat_luat_bin.c luat_main.c luat_malloc_weak.c
  group printf
    ../../../luat/packages/vsprintf/: printf.c
  group rt_usbd
    ../../../../rt-thread/components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../../rt-thread/components/drivers/usb/usbdevice/class/: mstorage.c
  group rtt
    ../../../luat/rtt/: luat_adc_rtt.c luat_crypto_rtt.c luat_disp_rtt.c luat_fs_rtt.c luat_gpio_rtt.c luat_http_rtt.c luat_i2c_rtt.c luat_lib_utest.c luat_lib_wlan.c luat_malloc_rtt.c luat_msgbus_rtt.c luat_msh_rtt.c luat_netclient_rtt.c luat_pwm_rtt.c luat_rtt_base.c luat_socket_rtt.c luat_spi_rtt.c luat_sys_rtt.c luat_timer_rtt.c luat_uart_rtt.c rtt_airkiss.c webclient.c
  group STM32_HAL
    ../../../../rt-thread/bsp/stm32/libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../../rt-thread/bsp/stm32/libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_nor.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
  group Utilities
    ../../../../rt-thread/components/utilities/ulog/: ulog.c
    ../../../../rt-thread/components/utilities/ulog/backend/: console_be.c
    ../../../../rt-thread/components/utilities/ymodem/: ymodem.c ry_sy.c
