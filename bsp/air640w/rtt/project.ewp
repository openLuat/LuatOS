# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __inline=inline; __inline__=inline; WM_W600; __inline=inline; __inline__=inline; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\net\sal_socket\include\socket; ..\..\components\net\lwip-2.0.2\src\include\ipv4; packages\wm_libraries-latest\Platform\Boot\gcc; oneshot; ..\..\components\net\sal_socket\include; ..\..\include; ..\..\components\net\lwip-2.0.2\src\include\netif; ..\..\components\libc\compilers\dlib; ..\..\components\net\sal_socket\include\dfs_net; ..\..\components\drivers\include; ..\..\libcpu\arm\common; packages\wm_libraries-latest\Include; ..\..\components\dfs\filesystems\devfs; packages\wm_libraries-latest\Platform\Common\crypto\symmetric; ..\..\components\net\lwip-2.0.2\src; drivers; ..\..\components\libc\compilers\common; packages\wm_libraries-latest\Platform\Common\crypto\digest; ..\..\components\net\sal_socket\include\dfs_net\sys_select; .; packages\wm_libraries-latest\Include\OS; ..\..\components\utilities\ulog; ..\..\libcpu\arm\cortex-m3; packages\netutils-v1.1.0\ntp; packages\wm_libraries-latest\Include\Platform; ..\..\components\drivers\hwcrypto; ..\..\components\dfs\include; packages\wm_libraries-latest\Platform\Inc; ..\..\components\net\sal_socket\include\socket\sys_socket; ..\..\components\net\lwip-2.0.2\src\include; ..\..\components\net\sal_socket\impl; packages\wm_libraries-latest\Platform\Common\Params; packages\wm_libraries-latest\Include\WiFi; packages\wm_libraries-latest\Platform\Common\crypto; packages\wm_libraries-latest\Platform\Drivers\spi; ..\..\components\drivers\spi; packages\wm_libraries-latest\Platform\Common\crypto\math; applications; ..\..\components\net\netdev\include; ..\..\components\finsh; ..\..\components\net\lwip_dhcpd; packages\wm_libraries-latest\Include\Driver; ..\..\components\drivers\wlan; ..\..\components\net\lwip-2.0.2\src\arch\include; packages\wm_libraries-latest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread.bin
  postbuild: cmd /c "makeimg.bat"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: .\drivers\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: packages\wm_libraries-latest\Lib\Wlan\libwlan_iar.a; packages\wm_libraries-latest\Lib\oneshot\libwmoneshot_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_uart.c drv_flash.c pin_map.c drv_wifi.c drv_pin.c
  group oneshot
    oneshot/: oneshot.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
  group Libraries
    packages/wm_libraries-latest/Platform/Drivers/cpu/: wm_cpu.c
    packages/wm_libraries-latest/Platform/Drivers/gpio/: wm_gpio.c wm_gpio_afsel.c
    packages/wm_libraries-latest/Platform/Drivers/io/: wm_io.c
    packages/wm_libraries-latest/Platform/Drivers/irq/: wm_irq.c
    packages/wm_libraries-latest/Platform/Drivers/efuse/: wm_efuse.c
    packages/wm_libraries-latest/Platform/Drivers/internalflash/: wm_internal_fls.c
    packages/wm_libraries-latest/Platform/Drivers/spi/: wm_hostspi.c
    packages/wm_libraries-latest/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    packages/wm_libraries-latest/Platform/Drivers/dma/: wm_dma.c
    packages/wm_libraries-latest/Platform/Drivers/timer/: wm_timer.c
    packages/wm_libraries-latest/Platform/Drivers/watchdog/: wm_watchdog.c
    packages/wm_libraries-latest/Platform/Drivers/i2c/: wm_i2c.c
    packages/wm_libraries-latest/Platform/Drivers/pwm/: wm_pwm.c
    packages/wm_libraries-latest/Platform/Drivers/adc/: wm_adc.c
    packages/wm_libraries-latest/Platform/Drivers/pmu/: wm_pmu.c
    packages/wm_libraries-latest/Platform/Drivers/rtc/: wm_rtc.c
    packages/wm_libraries-latest/Platform/Common/Params/: wm_param.c
    packages/wm_libraries-latest/Platform/Common/fwup/: wm_fwup.c
    packages/wm_libraries-latest/Platform/Common/crypto/: wm_crypto_hard.c
    packages/wm_libraries-latest/Platform/Common/crypto/digest/: wm_crypto_hmac.c wm_crypto_md2.c wm_crypto_md4.c sha224.c sha384.c wm_crypto_sha512.c
    packages/wm_libraries-latest/Platform/Common/crypto/keyformat/: asn1.c wm_crypto_base64.c wm_crypto_x509.c
    packages/wm_libraries-latest/Platform/Common/crypto/math/: pstm_mul_comba.c
    packages/wm_libraries-latest/Platform/Common/crypto/prng/: prng.c yarrow.c
    packages/wm_libraries-latest/Platform/Common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c wm_crypto_rsa.c
    packages/wm_libraries-latest/Platform/Common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    packages/wm_libraries-latest/rtthread/: rtthread_patch.c
    packages/wm_libraries-latest/rtthread/utils/: utils.c
    packages/wm_libraries-latest/rtthread/startup/iar/: startup_venus.S
    packages/wm_libraries-latest/Platform/Boot/iar/: misc.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../components/drivers/hwcrypto/: hwcrypto.c hw_symmetric.c hw_hash.c hw_rng.c hw_crc.c hw_bignum.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../components/drivers/rtc/: rtc.c soft_rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/watchdog/: watchdog.c
    ../../components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group lwIP
    ../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
    ../../components/net/lwip_dhcpd/: dhcp_server_raw.c
  group netdev
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../components/net/sal_socket/src/: sal_socket.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/impl/: af_inet_lwip.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    ../../components/utilities/ulog/: ulog.c
    ../../components/utilities/ulog/backend/: console_be.c
