/*
 * nfs_ecc.c — Software Hamming ECC for NFS
 *
 * Ported from yaffs_ecc.c (YAFFS2).  The column parity table covers
 * 8 columns of a byte; line parity accumulates over all bytes.
 * Detects and corrects 1-bit errors; detects (but does not correct)
 * 2-bit errors.
 */

#include "nfs_ecc.h"

/*-------------------------------------------------------------------
 *  column_parity_table[byte]
 *
 *  bit  purpose
 *   0   p1   (column parity for bit column 0,2,4,6)
 *   1   p1'  (column parity for bit column 1,3,5,7)
 *   2   p2   (column parity for bit column 0,1,4,5)
 *   3   p2'  (column parity for bit column 2,3,6,7)
 *   4   p4   (column parity for bit column 0,1,2,3)
 *   5   p4'  (column parity for bit column 4,5,6,7)
 *
 * Generated once offline; stored as a lookup table for speed.
 *-------------------------------------------------------------------*/

static const nfs_u8 column_parity_table[256] = {
    0x00, 0x55, 0x56, 0x03, 0x59, 0x0c, 0x0f, 0x5a,
    0x5a, 0x0f, 0x0c, 0x59, 0x03, 0x56, 0x55, 0x00,
    0x65, 0x30, 0x33, 0x66, 0x3c, 0x69, 0x6a, 0x3f,
    0x3f, 0x6a, 0x69, 0x3c, 0x66, 0x33, 0x30, 0x65,
    0x66, 0x33, 0x30, 0x65, 0x3f, 0x6a, 0x69, 0x3c,
    0x3c, 0x69, 0x6a, 0x3f, 0x65, 0x30, 0x33, 0x66,
    0x03, 0x56, 0x55, 0x00, 0x5a, 0x0f, 0x0c, 0x59,
    0x59, 0x0c, 0x0f, 0x5a, 0x00, 0x55, 0x56, 0x03,
    0x69, 0x3c, 0x3f, 0x6a, 0x30, 0x65, 0x66, 0x33,
    0x33, 0x66, 0x65, 0x30, 0x6a, 0x3f, 0x3c, 0x69,
    0x0c, 0x59, 0x5a, 0x0f, 0x55, 0x00, 0x03, 0x56,
    0x56, 0x03, 0x00, 0x55, 0x0f, 0x5a, 0x59, 0x0c,
    0x0f, 0x5a, 0x59, 0x0c, 0x56, 0x03, 0x00, 0x55,
    0x55, 0x00, 0x03, 0x56, 0x0c, 0x59, 0x5a, 0x0f,
    0x6a, 0x3f, 0x3c, 0x69, 0x33, 0x66, 0x65, 0x30,
    0x30, 0x65, 0x66, 0x33, 0x69, 0x3c, 0x3f, 0x6a,
    0x6a, 0x3f, 0x3c, 0x69, 0x33, 0x66, 0x65, 0x30,
    0x30, 0x65, 0x66, 0x33, 0x69, 0x3c, 0x3f, 0x6a,
    0x0f, 0x5a, 0x59, 0x0c, 0x56, 0x03, 0x00, 0x55,
    0x55, 0x00, 0x03, 0x56, 0x0c, 0x59, 0x5a, 0x0f,
    0x0c, 0x59, 0x5a, 0x0f, 0x55, 0x00, 0x03, 0x56,
    0x56, 0x03, 0x00, 0x55, 0x0f, 0x5a, 0x59, 0x0c,
    0x69, 0x3c, 0x3f, 0x6a, 0x30, 0x65, 0x66, 0x33,
    0x33, 0x66, 0x65, 0x30, 0x6a, 0x3f, 0x3c, 0x69,
    0x03, 0x56, 0x55, 0x00, 0x5a, 0x0f, 0x0c, 0x59,
    0x59, 0x0c, 0x0f, 0x5a, 0x00, 0x55, 0x56, 0x03,
    0x66, 0x33, 0x30, 0x65, 0x3f, 0x6a, 0x69, 0x3c,
    0x3c, 0x69, 0x6a, 0x3f, 0x65, 0x30, 0x33, 0x66,
    0x65, 0x30, 0x33, 0x66, 0x3c, 0x69, 0x6a, 0x3f,
    0x3f, 0x6a, 0x69, 0x3c, 0x66, 0x33, 0x30, 0x65,
    0x00, 0x55, 0x56, 0x03, 0x59, 0x0c, 0x0f, 0x5a,
    0x5a, 0x0f, 0x0c, 0x59, 0x03, 0x56, 0x55, 0x00,
};

/*-------------------------------------------------------------------
 *  nfs_ecc_calc_other
 *-------------------------------------------------------------------*/

void nfs_ecc_calc_other(const nfs_u8 *data, nfs_u32 n_bytes,
                        nfs_ecc_other_t *ecc)
{
    nfs_u32  i;
    nfs_u8   col;
    nfs_u32  line_parity       = 0;
    nfs_u32  line_parity_prime = 0;

    ecc->col_parity = 0;

    for (i = 0; i < n_bytes; i++) {
        col = column_parity_table[data[i]];
        ecc->col_parity ^= col;

        if (col & 1) {
            /* odd column parity: this byte contributes to line parity */
            line_parity       ^= i;
            line_parity_prime ^= ~i;
        }
    }

    ecc->line_parity       = line_parity;
    ecc->line_parity_prime = line_parity_prime;
}

/*-------------------------------------------------------------------
 *  nfs_ecc_correct_other
 *-------------------------------------------------------------------*/

int nfs_ecc_correct_other(nfs_u8 *data, nfs_u32 n_bytes,
                          nfs_ecc_other_t *read_ecc,
                          const nfs_ecc_other_t *calc_ecc)
{
    nfs_u8  diff_col;
    nfs_u32 diff_line;
    nfs_u32 diff_line_prime;
    nfs_u32 bit;

    diff_col        = read_ecc->col_parity       ^ calc_ecc->col_parity;
    diff_line       = read_ecc->line_parity       ^ calc_ecc->line_parity;
    diff_line_prime = read_ecc->line_parity_prime ^ calc_ecc->line_parity_prime;

    if (!diff_col && !diff_line && !diff_line_prime)
        return 0;   /* no error */

    if ((diff_line ^ diff_line_prime) == (nfs_u32)(n_bytes - 1)) {
        /* Single-bit error: locate the bit */
        bit  = 0;
        if (diff_col & 0x02) bit |= 1;
        if (diff_col & 0x08) bit |= 2;
        if (diff_col & 0x20) bit |= 4;

        /* Correct in place and update stored ECC */
        data[diff_line] ^= (nfs_u8)(1 << bit);
        read_ecc->col_parity       = calc_ecc->col_parity;
        read_ecc->line_parity      = calc_ecc->line_parity;
        read_ecc->line_parity_prime= calc_ecc->line_parity_prime;
        return 1;   /* corrected */
    }

    /* Uncorrectable */
    return -1;
}
